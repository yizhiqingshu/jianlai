# Keil uVision project cegong.uvprojx, settings and files
target cegong (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: cegong +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\MY_Files\HMI;..\MY_Files\contorl;..\MY_Files\Tcp;..\MY_Files\Middlewares\LwIP\src\api;..\MY_Files\Middlewares\LwIP\src\include;..\MY_Files\Middlewares\LwIP\src\include\posix;..\MY_Files\Middlewares\LwIP\src\include\netif;..\MY_Files\Middlewares\LwIP\src\include\lwip;..\MY_Files\Middlewares\LwIP\system;..\MY_Files\ZLG9518S;..\MY_Files\TS5303N616;..\MY_Files\RS232;..\MY_Files\Modebus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: sys.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c adc.c usart.c tim.c gpio.c dac.c
    ../: read_me.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group TS5303N616
    ../MY_Files/TS5303N616/: TS5303N616_3.c
  group ZLG9518S
    ../MY_Files/ZLG9518S/: ZLG.c
  group TCP
    ../MY_Files/Tcp/: app_ethernet.c ethernetif.c tcp_echoclient.c
  group Control
    ../MY_Files/contorl/: control.c stm_flash.c
    ../MY_Files/TS5303N616/: Speed.c
  group Middlewares/Api
    ../MY_Files/Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Core
    ../MY_Files/Middlewares/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/ipv4
    ../MY_Files/Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/netf
    ../MY_Files/Middlewares/LwIP/src/netif/: ethernet.c
  group RS232
    ../MY_Files/RS232/: FTH-2.c VMT_2000.c 50B.c MQW5102.c
  group HMI
    ../MY_Files/HMI/: MY_Talk.c
  group Modebus
    ../MY_Files/Modebus/: MB_host.c
software components: CMSIS:CORE 4.3.0
